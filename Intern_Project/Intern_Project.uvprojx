# Keil uVision project Intern_Project.uvprojx, settings and files
target STM32l053 Nucleo Board (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Intern_Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ./: Intern_Project.c
  group Drivers
    ./: ADC.c GPIO.c HTS221.c I2C.c Retarget.c Serial.c Timing.c LPS25HB.c
  group New Group
    ./: ADC_Test.c Gpio_Test.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
